# Keil uVision project new_gowin_proj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: new_gowin_proj
  AfterMake: fromelf.exe --bin -o new_gowin_proj.bin .\Objects\new_gowin_proj.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CORE;.\PERIPHERAL\Includes;.\SYSTEM;.\USER;.\MODULE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./CORE/: core_cm3.c
    ./PERIPHERAL/Sources/: gw1ns4c_gpio.c gw1ns4c_i2c.c gw1ns4c_rtc.c gw1ns4c_uart.c systick.c gw1ns4c_misc.c
    ./STARTUP/: startup_gw1ns4c.s
    ./SYSTEM/: system_gw1ns4c.c
    ./USER/: gw1ns4c_it.c main.c retarget.c
    ./MODULE/OLED/: oled.c
